# IAR project feibi.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151F3 STM8L151F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x190
  General.GenHeapSize: 0x00
  ICCSTM8.CCDefines: STM8L05X_MD_VL
  ICCSTM8.CCIncludePath2: ..\; ..\STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\src; ..\STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\inc; ..\APP; APP
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: junhe_26.s19
  ILINK.IlinkOutputFile: feibi.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP
    ../APP/: comm.c command.c eeprom.c main.c stm8l15x_it.c usart.c
  group feibi
    app/: bsp.c bsp.h protocol.c protocol.h userdata.c
  group STM8L15x-16x-05x-AL31-L_StdPeriph_Lib/src
    ../STM8L15x-16x-05x-AL31-L_StdPeriph_Lib/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
